require recipes-core/images/core-image-minimal.bb

IMAGE_INSTALL += " \
	github.com-influxdata-influxdb \
"
